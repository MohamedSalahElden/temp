<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>lora_lora_receiver</key>
<param><key>id</key><value>lora_lora_receiver_0</value></param>
<param><key>bandwidth</key><value>125000</value></param>
<param><key>crc</key><value>True</value></param>
<param><key>center_freq</key><value>868e6</value></param>
<param><key>channel_list</key><value>[868.1e6]</value></param>
<param><key>cr</key><value>4</value></param>
<param><key>conj</key><value>False</value></param>
<param><key>decimation</key><value>1</value></param>
<param><key>disable_channelization</key><value>False</value></param>
<param><key>disable_drift_correction</key><value>False</value></param>
<param><key>implicit</key><value>False</value></param>
<param><key>reduced_rate</key><value>False</value></param>
<param><key>samp_rate</key><value>1e6</value></param>
<param><key>sf</key><value>7</value></param>
</block>
<block>
<key>lora_lora_receiver</key>
<param><key>id</key><value>lora_lora_receiver_0_0</value></param>
<param><key>bandwidth</key><value>125000</value></param>
<param><key>crc</key><value>True</value></param>
<param><key>center_freq</key><value>868e6</value></param>
<param><key>channel_list</key><value>[868.1e6]</value></param>
<param><key>cr</key><value>4</value></param>
<param><key>conj</key><value>False</value></param>
<param><key>decimation</key><value>1</value></param>
<param><key>disable_channelization</key><value>False</value></param>
<param><key>disable_drift_correction</key><value>False</value></param>
<param><key>implicit</key><value>False</value></param>
<param><key>reduced_rate</key><value>False</value></param>
<param><key>samp_rate</key><value>1e6</value></param>
<param><key>sf</key><value>9</value></param>
</block>
<block>
<key>lora_lora_receiver</key>
<param><key>id</key><value>lora_lora_receiver_0_1</value></param>
<param><key>bandwidth</key><value>125000</value></param>
<param><key>crc</key><value>True</value></param>
<param><key>center_freq</key><value>868e6</value></param>
<param><key>channel_list</key><value>[868.1e6]</value></param>
<param><key>cr</key><value>4</value></param>
<param><key>conj</key><value>False</value></param>
<param><key>decimation</key><value>1</value></param>
<param><key>disable_channelization</key><value>False</value></param>
<param><key>disable_drift_correction</key><value>False</value></param>
<param><key>implicit</key><value>False</value></param>
<param><key>reduced_rate</key><value>False</value></param>
<param><key>samp_rate</key><value>1e6</value></param>
<param><key>sf</key><value>12</value></param>
</block>
<block>
<key>lora_lora_receiver</key>
<param><key>id</key><value>lora_lora_receiver_0_1_0</value></param>
<param><key>bandwidth</key><value>125000</value></param>
<param><key>crc</key><value>True</value></param>
<param><key>center_freq</key><value>868e6</value></param>
<param><key>channel_list</key><value>[868.1e6]</value></param>
<param><key>cr</key><value>4</value></param>
<param><key>conj</key><value>False</value></param>
<param><key>decimation</key><value>1</value></param>
<param><key>disable_channelization</key><value>False</value></param>
<param><key>disable_drift_correction</key><value>False</value></param>
<param><key>implicit</key><value>False</value></param>
<param><key>reduced_rate</key><value>False</value></param>
<param><key>samp_rate</key><value>1e6</value></param>
<param><key>sf</key><value>8</value></param>
</block>
<block>
<key>lora_lora_receiver</key>
<param><key>id</key><value>lora_lora_receiver_0_1_0_0</value></param>
<param><key>bandwidth</key><value>125000</value></param>
<param><key>crc</key><value>True</value></param>
<param><key>center_freq</key><value>868e6</value></param>
<param><key>channel_list</key><value>[868.1e6]</value></param>
<param><key>cr</key><value>4</value></param>
<param><key>conj</key><value>False</value></param>
<param><key>decimation</key><value>1</value></param>
<param><key>disable_channelization</key><value>False</value></param>
<param><key>disable_drift_correction</key><value>False</value></param>
<param><key>implicit</key><value>False</value></param>
<param><key>reduced_rate</key><value>False</value></param>
<param><key>samp_rate</key><value>1e6</value></param>
<param><key>sf</key><value>10</value></param>
</block>
<block>
<key>lora_lora_receiver</key>
<param><key>id</key><value>lora_lora_receiver_1</value></param>
<param><key>bandwidth</key><value>125000</value></param>
<param><key>crc</key><value>True</value></param>
<param><key>center_freq</key><value>868e6</value></param>
<param><key>channel_list</key><value>[868.5e6]</value></param>
<param><key>cr</key><value>4</value></param>
<param><key>conj</key><value>False</value></param>
<param><key>decimation</key><value>1</value></param>
<param><key>disable_channelization</key><value>False</value></param>
<param><key>disable_drift_correction</key><value>False</value></param>
<param><key>implicit</key><value>False</value></param>
<param><key>reduced_rate</key><value>False</value></param>
<param><key>samp_rate</key><value>1e6</value></param>
<param><key>sf</key><value>7</value></param>
</block>
<block>
<key>lora_lora_receiver</key>
<param><key>id</key><value>lora_lora_receiver_1_0</value></param>
<param><key>bandwidth</key><value>125000</value></param>
<param><key>crc</key><value>True</value></param>
<param><key>center_freq</key><value>868e6</value></param>
<param><key>channel_list</key><value>[868.3e6]</value></param>
<param><key>cr</key><value>4</value></param>
<param><key>conj</key><value>False</value></param>
<param><key>decimation</key><value>1</value></param>
<param><key>disable_channelization</key><value>False</value></param>
<param><key>disable_drift_correction</key><value>False</value></param>
<param><key>implicit</key><value>False</value></param>
<param><key>reduced_rate</key><value>False</value></param>
<param><key>samp_rate</key><value>1e6</value></param>
<param><key>sf</key><value>7</value></param>
</block>
<block>
<key>lora_lora_receiver</key>
<param><key>id</key><value>lora_lora_receiver_1_0_0</value></param>
<param><key>bandwidth</key><value>125000</value></param>
<param><key>crc</key><value>True</value></param>
<param><key>center_freq</key><value>868e6</value></param>
<param><key>channel_list</key><value>[868.3e6]</value></param>
<param><key>cr</key><value>4</value></param>
<param><key>conj</key><value>False</value></param>
<param><key>decimation</key><value>1</value></param>
<param><key>disable_channelization</key><value>False</value></param>
<param><key>disable_drift_correction</key><value>False</value></param>
<param><key>implicit</key><value>False</value></param>
<param><key>reduced_rate</key><value>False</value></param>
<param><key>samp_rate</key><value>1e6</value></param>
<param><key>sf</key><value>9</value></param>
</block>
<block>
<key>lora_lora_receiver</key>
<param><key>id</key><value>lora_lora_receiver_1_0_1</value></param>
<param><key>bandwidth</key><value>125000</value></param>
<param><key>crc</key><value>True</value></param>
<param><key>center_freq</key><value>868e6</value></param>
<param><key>channel_list</key><value>[868.3e6]</value></param>
<param><key>cr</key><value>4</value></param>
<param><key>conj</key><value>False</value></param>
<param><key>decimation</key><value>1</value></param>
<param><key>disable_channelization</key><value>False</value></param>
<param><key>disable_drift_correction</key><value>False</value></param>
<param><key>implicit</key><value>False</value></param>
<param><key>reduced_rate</key><value>False</value></param>
<param><key>samp_rate</key><value>1e6</value></param>
<param><key>sf</key><value>12</value></param>
</block>
<block>
<key>lora_lora_receiver</key>
<param><key>id</key><value>lora_lora_receiver_1_0_1_0</value></param>
<param><key>bandwidth</key><value>125000</value></param>
<param><key>crc</key><value>True</value></param>
<param><key>center_freq</key><value>868e6</value></param>
<param><key>channel_list</key><value>[868.3e6]</value></param>
<param><key>cr</key><value>4</value></param>
<param><key>conj</key><value>False</value></param>
<param><key>decimation</key><value>1</value></param>
<param><key>disable_channelization</key><value>False</value></param>
<param><key>disable_drift_correction</key><value>False</value></param>
<param><key>implicit</key><value>False</value></param>
<param><key>reduced_rate</key><value>False</value></param>
<param><key>samp_rate</key><value>1e6</value></param>
<param><key>sf</key><value>8</value></param>
</block>
<block>
<key>lora_lora_receiver</key>
<param><key>id</key><value>lora_lora_receiver_1_0_1_0_0</value></param>
<param><key>bandwidth</key><value>125000</value></param>
<param><key>crc</key><value>True</value></param>
<param><key>center_freq</key><value>868e6</value></param>
<param><key>channel_list</key><value>[868.3e6]</value></param>
<param><key>cr</key><value>4</value></param>
<param><key>conj</key><value>False</value></param>
<param><key>decimation</key><value>1</value></param>
<param><key>disable_channelization</key><value>False</value></param>
<param><key>disable_drift_correction</key><value>False</value></param>
<param><key>implicit</key><value>False</value></param>
<param><key>reduced_rate</key><value>False</value></param>
<param><key>samp_rate</key><value>1e6</value></param>
<param><key>sf</key><value>10</value></param>
</block>
<block>
<key>lora_lora_receiver</key>
<param><key>id</key><value>lora_lora_receiver_1_1</value></param>
<param><key>bandwidth</key><value>125000</value></param>
<param><key>crc</key><value>True</value></param>
<param><key>center_freq</key><value>868e6</value></param>
<param><key>channel_list</key><value>[868.5e6]</value></param>
<param><key>cr</key><value>4</value></param>
<param><key>conj</key><value>False</value></param>
<param><key>decimation</key><value>1</value></param>
<param><key>disable_channelization</key><value>False</value></param>
<param><key>disable_drift_correction</key><value>False</value></param>
<param><key>implicit</key><value>False</value></param>
<param><key>reduced_rate</key><value>False</value></param>
<param><key>samp_rate</key><value>1e6</value></param>
<param><key>sf</key><value>9</value></param>
</block>
<block>
<key>lora_lora_receiver</key>
<param><key>id</key><value>lora_lora_receiver_1_2</value></param>
<param><key>bandwidth</key><value>125000</value></param>
<param><key>crc</key><value>True</value></param>
<param><key>center_freq</key><value>868e6</value></param>
<param><key>channel_list</key><value>[868.5e6]</value></param>
<param><key>cr</key><value>4</value></param>
<param><key>conj</key><value>False</value></param>
<param><key>decimation</key><value>1</value></param>
<param><key>disable_channelization</key><value>False</value></param>
<param><key>disable_drift_correction</key><value>False</value></param>
<param><key>implicit</key><value>False</value></param>
<param><key>reduced_rate</key><value>False</value></param>
<param><key>samp_rate</key><value>1e6</value></param>
<param><key>sf</key><value>12</value></param>
</block>
<block>
<key>lora_lora_receiver</key>
<param><key>id</key><value>lora_lora_receiver_1_2_0</value></param>
<param><key>bandwidth</key><value>125000</value></param>
<param><key>crc</key><value>True</value></param>
<param><key>center_freq</key><value>868e6</value></param>
<param><key>channel_list</key><value>[868.5e6]</value></param>
<param><key>cr</key><value>4</value></param>
<param><key>conj</key><value>False</value></param>
<param><key>decimation</key><value>1</value></param>
<param><key>disable_channelization</key><value>False</value></param>
<param><key>disable_drift_correction</key><value>False</value></param>
<param><key>implicit</key><value>False</value></param>
<param><key>reduced_rate</key><value>False</value></param>
<param><key>samp_rate</key><value>1e6</value></param>
<param><key>sf</key><value>8</value></param>
</block>
<block>
<key>lora_lora_receiver</key>
<param><key>id</key><value>lora_lora_receiver_1_2_0_0</value></param>
<param><key>bandwidth</key><value>125000</value></param>
<param><key>crc</key><value>True</value></param>
<param><key>center_freq</key><value>868e6</value></param>
<param><key>channel_list</key><value>[868.5e6]</value></param>
<param><key>cr</key><value>4</value></param>
<param><key>conj</key><value>False</value></param>
<param><key>decimation</key><value>1</value></param>
<param><key>disable_channelization</key><value>False</value></param>
<param><key>disable_drift_correction</key><value>False</value></param>
<param><key>implicit</key><value>False</value></param>
<param><key>reduced_rate</key><value>False</value></param>
<param><key>samp_rate</key><value>1e6</value></param>
<param><key>sf</key><value>10</value></param>
</block>
<block>
<key>lora_message_socket_sink</key>
<param><key>id</key><value>lora_message_socket_sink_0</value></param>
<param><key>ip</key><value>127.0.0.1</value></param>
<param><key>layer</key><value>0</value></param>
<param><key>port</key><value>40868</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>1e6</value></param>
<param><key>freq0</key><value>868e6</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>1e6</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>868e6</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>1e6</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>868e6</value></param>
<param><key>dynamic_range</key><value>100</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>samp_rate</key><value>1e6</value></param>
<param><key>title</key><value>Waterfall Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
</block>
<connection><source_block_id>lora_lora_receiver_0</source_block_id><sink_block_id>lora_message_socket_sink_0</sink_block_id><source_key>frames</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lora_lora_receiver_0_0</source_block_id><sink_block_id>lora_message_socket_sink_0</sink_block_id><source_key>frames</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lora_lora_receiver_0_1</source_block_id><sink_block_id>lora_message_socket_sink_0</sink_block_id><source_key>frames</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lora_lora_receiver_0_1_0</source_block_id><sink_block_id>lora_message_socket_sink_0</sink_block_id><source_key>frames</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lora_lora_receiver_0_1_0_0</source_block_id><sink_block_id>lora_message_socket_sink_0</sink_block_id><source_key>frames</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lora_lora_receiver_1</source_block_id><sink_block_id>lora_message_socket_sink_0</sink_block_id><source_key>frames</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lora_lora_receiver_1_0</source_block_id><sink_block_id>lora_message_socket_sink_0</sink_block_id><source_key>frames</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lora_lora_receiver_1_0_0</source_block_id><sink_block_id>lora_message_socket_sink_0</sink_block_id><source_key>frames</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lora_lora_receiver_1_0_1</source_block_id><sink_block_id>lora_message_socket_sink_0</sink_block_id><source_key>frames</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lora_lora_receiver_1_0_1_0</source_block_id><sink_block_id>lora_message_socket_sink_0</sink_block_id><source_key>frames</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lora_lora_receiver_1_0_1_0_0</source_block_id><sink_block_id>lora_message_socket_sink_0</sink_block_id><source_key>frames</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lora_lora_receiver_1_1</source_block_id><sink_block_id>lora_message_socket_sink_0</sink_block_id><source_key>frames</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lora_lora_receiver_1_2</source_block_id><sink_block_id>lora_message_socket_sink_0</sink_block_id><source_key>frames</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lora_lora_receiver_1_2_0</source_block_id><sink_block_id>lora_message_socket_sink_0</sink_block_id><source_key>frames</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lora_lora_receiver_1_2_0_0</source_block_id><sink_block_id>lora_message_socket_sink_0</sink_block_id><source_key>frames</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>lora_lora_receiver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>lora_lora_receiver_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>lora_lora_receiver_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>lora_lora_receiver_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>lora_lora_receiver_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>lora_lora_receiver_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>lora_lora_receiver_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>lora_lora_receiver_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>lora_lora_receiver_1_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>lora_lora_receiver_1_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>lora_lora_receiver_1_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>lora_lora_receiver_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>lora_lora_receiver_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>lora_lora_receiver_1_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>lora_lora_receiver_1_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
